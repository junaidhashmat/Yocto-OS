FILESEXTRAPATHS:prepend := "${THISDIR}/qoriq-atf:"


SRC_URI += "file://0001-port-1046frywy-ddr-cfgs-to-1046ardp.patch"
